# Keil uVision project TLx49012_TLE987x_IntegrationExample.uvprojx, settings and files
target src (6240000::V6.24::ARMCLANG)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.6.2
  cpu: IRAM(0x18000018,0x17E8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TLx49012_TLE987x_IntegrationExample
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0x17e8
  memory RVCT10: RAM 0x18000000 size 0x10
  group main
    ./src/: main.c
  group Controller
    ./src/Controller/TLE987x_SPI/: TLE987x_SPI.c TLE987x_SPI.h
    ./src/Controller/TLE987x_GPIO/: TLE987x_GPIO.c TLE987x_GPIO.h
    ./src/Controller/TLE987x_UART/: TLE987x_UART.h
  group Interface
    ./src/Sensor/Interface/CRC8_SAE_J1850/: CRC8_SAE_J1850.c CRC8_SAE_J1850.h
    ./src/Sensor/Interface/SPI_Frontend/: SPIFrontend.c SPIFrontend.h
  group Sensor
    ./src/Sensor/: TLx49012.c TLx49012.h
software components: CMSIS:CORE 6.2.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:BOOTROM 0.3.4, Device:SDK:DMA 0.2.7, Device:SDK:INT 0.2.4, Device:SDK:ISR 0.3.0, Device:SDK:LIN 0.2.1, Device:SDK:PMU 0.2.3, Device:SDK:PORT 0.6.1, Device:SDK:SCU 0.5.9, Device:SDK:SSC 0.1.9, Device:SDK:UART 0.2.5, Device:SDK:WDT1 0.3.4, Device:Startup 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
